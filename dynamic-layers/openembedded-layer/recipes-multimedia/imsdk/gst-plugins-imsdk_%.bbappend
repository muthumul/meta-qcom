PACKAGECONFIG:append = " ml messaging sample-apps"

